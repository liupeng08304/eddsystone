# Keil uVision project eddsytone.uvproj, settings and files
target eddsytone (ARM-ADS)
  device: nRF52832_xxAA Nordic Semiconductor
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(64000000) ELITTLE
  output: eddsytone +hex
  c flags: Optim=1 OneElfS=1
  c define: BOARD_PCA10040 NRF52 NRF52832_XXAA NRF52_PAN_74 NRF_SD_BLE_API_VERSION=5 S132 SOFTDEVICE_PRESENT SWI_DISABLE0 CONFIG_NFCT_PINS_AS_GPIOS
  c misc: --c99 --reduce_paths
  c include: ..\prj;..\components;..\components\ble\ble_advertising;..\components\ble\ble_dtm;..\components\ble\ble_racp;..\components\ble\ble_services\ble_ancs_c;..\components\ble\ble_services\ble_ans_c;..\components\ble\ble_services\ble_bas;..\components\ble\ble_services\ble_bas_c;..\components\ble\ble_services\ble_cscs;..\components\ble\ble_services\ble_cts_c;..\components\ble\ble_services\ble_dfu;..\components\ble\ble_services\ble_dis;..\components\ble\ble_services\ble_escs;..\components\ble\ble_services\ble_gls;..\components\ble\ble_services\ble_hids;..\components\ble\ble_services\ble_hrs;..\components\ble\ble_services\ble_hrs_c;..\components\ble\ble_services\ble_hts;..\components\ble\ble_services\ble_ias;..\components\ble\ble_services\ble_ias_c;..\components\ble\ble_services\ble_lbs;..\components\ble\ble_services\ble_lbs_c;..\components\ble\ble_services\ble_lls;..\components\ble\ble_services\ble_nus;..\components\ble\ble_services\ble_nus_c;..\components\ble\ble_services\ble_rscs;..\components\ble\ble_services\ble_rscs_c;..\components\ble\ble_services\ble_tps;..\components\ble\common;..\components\ble\nrf_ble_gatt;..\components\ble\nrf_ble_qwr;..\components\ble\peer_manager;..\components\boards;..\components\drivers_nrf\clock;..\components\drivers_nrf\common;..\components\drivers_nrf\comp;..\components\drivers_nrf\delay;..\components\drivers_nrf\gpiote;..\components\drivers_nrf\hal;..\components\drivers_nrf\i2s;..\components\drivers_nrf\lpcomp;..\components\drivers_nrf\pdm;..\components\drivers_nrf\power;..\components\drivers_nrf\ppi;..\components\drivers_nrf\pwm;..\components\drivers_nrf\qdec;..\components\drivers_nrf\rng;..\components\drivers_nrf\rtc;..\components\drivers_nrf\saadc;..\components\drivers_nrf\saadc;..\components\drivers_nrf\spi_master;..\components\drivers_nrf\spi_slave;..\components\drivers_nrf\swi;..\components\drivers_nrf\timer;..\components\drivers_nrf\twi_master;..\components\drivers_nrf\twis_slave;..\components\drivers_nrf\uart;..\components\drivers_nrf\usbd;..\components\drivers_nrf\wdt;..\components\libraries\atomic;..\components\libraries\atomic_fifo;..\components\libraries\balloc;..\components\libraries\bsp;..\components\libraries\button;..\components\libraries\crc16;..\components\libraries\crc32;..\components\libraries\csense;..\components\libraries\csense_drv;..\components\libraries\ecc;..\components\libraries\eddystone;..\components\libraries\experimental_cli;..\components\libraries\experimental_log;..\components\libraries\experimental_log\src;..\components\libraries\experimental_memobj;..\components\libraries\experimental_section_vars;..\components\libraries\fds;..\components\libraries\fstorage;..\components\libraries\gpiote;..\components\libraries\hardfault;..\components\libraries\hci;..\components\libraries\led_softblink;..\components\libraries\low_power_pwm;..\components\libraries\mem_manager;..\components\libraries\pwm;..\components\libraries\queue;..\components\libraries\scheduler;..\components\libraries\sensorsim;..\components\libraries\slip;..\components\libraries\strerror;..\components\libraries\timer;..\components\libraries\twi;..\components\libraries\uart;..\components\libraries\usbd;..\components\libraries\usbd\class\audio;..\components\libraries\usbd\class\cdc;..\components\libraries\usbd\class\cdc\acm;..\components\libraries\usbd\class\hid;..\components\libraries\usbd\class\hid\generic;..\components\libraries\usbd\class\hid\kbd;..\components\libraries\usbd\class\hid\mouse;..\components\libraries\usbd\class\msc;..\components\libraries\usbd\config;..\components\libraries\util;..\components\softdevice\common;..\components\softdevice\s132\headers;..\components\softdevice\s132\headers\nrf52;..\components\toolchain;..\moudle\occ\occ\OberonHAPCrypto;..\..\..\occ\occ\OberonHAPCryptoP256;..\..\..\occ\occ\OberonHAPCryptoP256\include;..\..\..\occ\occ\OberonHAPCrypto\include;..\external\cifra_AES128-EAX;..\external\tiny-AES128;..\components\device;..\moudle\occ\occ\OberonHAPCrypto\include;..\moudle\occ\occ\OberonHAPCrypto;.\config;..\components\toolchain;..\components\toolchain\cmsis\include
  asm define: BOARD_PCA10040 CONFIG_GPIO_AS_PINRESET NRF52 NRF52832_XXAA NRF52_PAN_74 NRF_SD_BLE_API_VERSION=5 S132 SOFTDEVICE_PRESENT SWI_DISABLE0
  asm misc: --cpreproc_opts=-DBLE_STACK_SUPPORT_REQD,-DBOARD_PCA10040,-DCONFIG_GPIO_AS_PINRESET,-DNRF52,-DNRF52832_XXAA,-DNRF52_PAN_12,-DNRF52_PAN_15,-DNRF52_PAN_20,-DNRF52_PAN_31,-DNRF52_PAN_36,-DNRF52_PAN_51,-DNRF52_PAN_54,-DNRF52_PAN_55,-DNRF52_PAN_58,-DNRF52_PAN_64,-DNRF52_PAN_74,-DNRF_SD_BLE_API_VERSION=4,-DS132,-DSOFTDEVICE_PRESENT,-DSWI_DISABLE0
  asm include: ..\..\..\config\ble_app_uart_pca10040_s132;..\..\..\config;..\..\..\..\..\..\components;..\..\..\..\..\..\components\ble\ble_advertising;..\..\..\..\..\..\components\ble\ble_dtm;..\..\..\..\..\..\components\ble\ble_racp;..\..\..\..\..\..\components\ble\ble_services\ble_ancs_c;..\..\..\..\..\..\components\ble\ble_services\ble_ans_c;..\..\..\..\..\..\components\ble\ble_services\ble_bas;..\..\..\..\..\..\components\ble\ble_services\ble_bas_c;..\..\..\..\..\..\components\ble\ble_services\ble_cscs;..\..\..\..\..\..\components\ble\ble_services\ble_cts_c;..\..\..\..\..\..\components\ble\ble_services\ble_dfu;..\..\..\..\..\..\components\ble\ble_services\ble_dis;..\..\..\..\..\..\components\ble\ble_services\ble_gls;..\..\..\..\..\..\components\ble\ble_services\ble_hids;..\..\..\..\..\..\components\ble\ble_services\ble_hrs;..\..\..\..\..\..\components\ble\ble_services\ble_hrs_c;..\..\..\..\..\..\components\ble\ble_services\ble_hts;..\..\..\..\..\..\components\ble\ble_services\ble_ias;..\..\..\..\..\..\components\ble\ble_services\ble_ias_c;..\..\..\..\..\..\components\ble\ble_services\ble_lbs;..\..\..\..\..\..\components\ble\ble_services\ble_lbs_c;..\..\..\..\..\..\components\ble\ble_services\ble_lls;..\..\..\..\..\..\components\ble\ble_services\ble_nus;..\..\..\..\..\..\components\ble\ble_services\ble_nus_c;..\..\..\..\..\..\components\ble\ble_services\ble_rscs;..\..\..\..\..\..\components\ble\ble_services\ble_rscs_c;..\..\..\..\..\..\components\ble\ble_services\ble_tps;..\..\..\..\..\..\components\ble\common;..\..\..\..\..\..\components\ble\nrf_ble_gatt;..\..\..\..\..\..\components\ble\nrf_ble_qwr;..\..\..\..\..\..\components\ble\peer_manager;..\..\..\..\..\..\components\boards;..\..\..\..\..\..\components\device;..\..\..\..\..\..\components\drivers_nrf\clock;..\..\..\..\..\..\components\drivers_nrf\common;..\..\..\..\..\..\components\drivers_nrf\comp;..\..\..\..\..\..\components\drivers_nrf\delay;..\..\..\..\..\..\components\drivers_nrf\gpiote;..\..\..\..\..\..\components\drivers_nrf\hal;..\..\..\..\..\..\components\drivers_nrf\i2s;..\..\..\..\..\..\components\drivers_nrf\lpcomp;..\..\..\..\..\..\components\drivers_nrf\pdm;..\..\..\..\..\..\components\drivers_nrf\power;..\..\..\..\..\..\components\drivers_nrf\ppi;..\..\..\..\..\..\components\drivers_nrf\pwm;..\..\..\..\..\..\components\drivers_nrf\qdec;..\..\..\..\..\..\components\drivers_nrf\rng;..\..\..\..\..\..\components\drivers_nrf\rtc;..\..\..\..\..\..\components\drivers_nrf\saadc;..\..\..\..\..\..\components\drivers_nrf\spi_master;..\..\..\..\..\..\components\drivers_nrf\spi_slave;..\..\..\..\..\..\components\drivers_nrf\swi;..\..\..\..\..\..\components\drivers_nrf\timer;..\..\..\..\..\..\components\drivers_nrf\twi_master;..\..\..\..\..\..\components\drivers_nrf\twis_slave;..\..\..\..\..\..\components\drivers_nrf\uart;..\..\..\..\..\..\components\drivers_nrf\usbd;..\..\..\..\..\..\components\drivers_nrf\wdt;..\..\..\..\..\..\components\libraries\bsp;..\..\..\..\..\..\components\libraries\button;..\..\..\..\..\..\components\libraries\crc16;..\..\..\..\..\..\components\libraries\crc32;..\..\..\..\..\..\components\libraries\csense;..\..\..\..\..\..\components\libraries\csense_drv;..\..\..\..\..\..\components\libraries\ecc;..\..\..\..\..\..\components\libraries\experimental_section_vars;..\..\..\..\..\..\components\libraries\fds;..\..\..\..\..\..\components\libraries\fifo;..\..\..\..\..\..\components\libraries\fstorage;..\..\..\..\..\..\components\libraries\gpiote;..\..\..\..\..\..\components\libraries\hardfault;..\..\..\..\..\..\components\libraries\hci;..\..\..\..\..\..\components\libraries\led_softblink;..\..\..\..\..\..\components\libraries\log;..\..\..\..\..\..\components\libraries\log\src;..\..\..\..\..\..\components\libraries\low_power_pwm;..\..\..\..\..\..\components\libraries\mem_manager;..\..\..\..\..\..\components\libraries\pwm;..\..\..\..\..\..\components\libraries\queue;..\..\..\..\..\..\components\libraries\scheduler;..\..\..\..\..\..\components\libraries\slip;..\..\..\..\..\..\components\libraries\strerror;..\..\..\..\..\..\components\libraries\timer;..\..\..\..\..\..\components\libraries\twi;..\..\..\..\..\..\components\libraries\uart;..\..\..\..\..\..\components\libraries\usbd;..\..\..\..\..\..\components\libraries\usbd\class\audio;..\..\..\..\..\..\components\libraries\usbd\class\cdc;..\..\..\..\..\..\components\libraries\usbd\class\cdc\acm;..\..\..\..\..\..\components\libraries\usbd\class\hid;..\..\..\..\..\..\components\libraries\usbd\class\hid\generic;..\..\..\..\..\..\components\libraries\usbd\class\hid\kbd;..\..\..\..\..\..\components\libraries\usbd\class\hid\mouse;..\..\..\..\..\..\components\libraries\usbd\class\msc;..\..\..\..\..\..\components\libraries\usbd\config;..\..\..\..\..\..\components\libraries\util;..\..\..\..\..\..\components\softdevice\common\softdevice_handler;..\..\..\..\..\..\components\softdevice\s132\headers;..\..\..\..\..\..\components\softdevice\s132\headers\nrf52;..\..\..\..\..\..\components\toolchain;..\..\..\..\..\..\external\segger_rtt;..\config
  library: MicroLIB
  memory RVCT4: ROM 0x23000 size 0x1e000
  memory RVCT9: RAM 0x20002180 size 0x6000
  link misc: --diag_suppress 6330
  group Application
    ./: main.c
    ./config/: sdk_config.h
  group Board Definition
    ../components/boards/: boards.c
  group Board Support
    ../components/libraries/bsp/: bsp.c bsp_btn_ble.c bsp_nfc.c
  group nRF_BLE
    ../components/ble/common/: ble_advdata.c ble_conn_params.c ble_conn_state.c ble_srv_common.c
    ../components/ble/ble_advertising/: ble_advertising.c
    ../components/ble/nrf_ble_gatt/: nrf_ble_gatt.c
  group nRF_BLE_Services
    ../components/ble/ble_services/ble_escs/: nrf_ble_escs.c
  group nRF_Drivers
    ../components/drivers_nrf/clock/: nrf_drv_clock.c
    ../components/drivers_nrf/common/: nrf_drv_common.c
    ../components/drivers_nrf/gpiote/: nrf_drv_gpiote.c
    ../components/drivers_nrf/saadc/: nrf_drv_saadc.c
    ../components/drivers_nrf/hal/: nrf_saadc.c
  group nRF_Libraries
    ../external/tiny-AES128/: aes.c
    ../components/libraries/button/: app_button.c
    ../components/libraries/util/: app_error.c app_error_weak.c app_util_platform.c nrf_assert.c sdk_mapped_flags.c
    ../components/libraries/scheduler/: app_scheduler.c
    ../components/libraries/timer/: app_timer.c
    ../external/cifra_AES128-EAX/: blockwise.c cifra_eax_aes.c cmac.c eax.c gf128.c modes.c
    ../components/libraries/crc16/: crc16.c
    ../components/libraries/eddystone/: es_adv.c es_adv_frame.c es_adv_timing.c es_adv_timing_resolver.c es_battery_voltage_saadc.c es_flash.c es_gatts.c es_gatts_read.c es_gatts_write.c es_security.c es_slot.c es_slot_reg.c es_stopwatch.c es_tlm.c nrf_ble_es.c
    ../components/libraries/fds/: fds.c
    ../components/libraries/hardfault/: hardfault_implementation.c
    ../components/libraries/atomic_fifo/: nrf_atfifo.c
    ../components/libraries/balloc/: nrf_balloc.c
    ../components/libraries/fstorage/: nrf_fstorage.c nrf_fstorage_sd.c
    ../components/libraries/experimental_memobj/: nrf_memobj.c
    ../components/libraries/experimental_section_vars/: nrf_section_iter.c
    ../components/libraries/strerror/: nrf_strerror.c
    ../components/libraries/sensorsim/: sensorsim.c
  group nRF_Log
    ../components/libraries/experimental_log/src/: nrf_log_frontend.c
  group nRF_OCC
    ../moudle/occ/: occ_lib_nrf52.lib
  group nRF_SoftDevice
    ../components/softdevice/common/: nrf_sdh.c nrf_sdh_ble.c nrf_sdh_soc.c
  group device
    ../components/toolchain/arm/: arm_startup_nrf52.s
    ../components/toolchain/: system_nrf52.c
